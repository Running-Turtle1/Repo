# Keil uVision project Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user;..\bsp\Eight_Multiple_Eight_LED_Matrix;..\bsp\IIC;..\bsp\timer;..\bsp\LCD1602A;..\bsp\DS1302
  group user
    ../user/: main.c public.c
  group bsp
    ../bsp/Eight_Multiple_Eight_LED_Matrix/: Eight_Multiple_Eight_LED_Matrix.c
    ../bsp/timer/: timer.c
    ../bsp/LCD1602A/: LCD1602.c
    ../bsp/DS1302/: DS1302.c
