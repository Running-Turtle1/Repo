# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp\DS;..\bsp\LCD;..\user;..\bsp\DS18;..\bsp\timer
  group user
    ../user/: main.c public.c
  group bsp
    ../bsp/DS/: DS.c
    ../bsp/LCD/: LCD.c
    ../bsp/DS18/: DS18.c
    ../bsp/timer/: timer.c
