# Keil uVision project module_template.uvproj, settings and files
target module_template (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: module_template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\public;..\bsp\led;..\bsp\key;..\bsp\smg;..\bsp\step_motor;..\bsp\iic;..\bsp\24c02;..\bsp\lcd1602;..\bsp\timer
  group user
    ../user/: main.c
  group public
    ../public/: public.c
  group bsp
    ../bsp/led/: led.c
    ../bsp/key/: key.c
    ../bsp/smg/: smg.c
    ../bsp/step_motor/: step_motor.c
    ../bsp/iic/: iic.c
    ../bsp/24c02/: 24c02.c
    ../bsp/lcd1602/: lcd1602.c
    ../bsp/timer/: timer.c
